# Keil uVision project MPD-1616.uvproj, settings and files
target Serial Load (ARM-ADS)
  device: NUC140VE3AN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: D8NN
  AfterMake: fromelf --bin ".\out\@L.axf" --output ".\out\@L.bin"
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\D8NN_Include;..\..\D8NN_Library
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC1xx.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS files
    ./: startup_NUC1xx.s
    ../../D8NN_Include/: system_NUC1xx.c
  group Source files
    ./: MPD_Font.c MPD-1616.c
  group Library files
    ../../D8NN_Library/: retarget.c DrvCAN.c DrvGPIO.c DrvSYS.c DrvUART.c DrvTIMER.c DrvSPI.c
target NuLink (ARM-ADS)
  device: NUC140VE3AN Nuvoton
  cpu: as above
  output: D8NN
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\D8NN_Include;..\..\D8NN_Library
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: as above
target ULINK2 JTAG (ARM-ADS)
  device: NUC140VE3AN Nuvoton
  cpu: as above
  output: D8NN
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\D8NN_Include;..\..\D8NN_Library
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: as above
